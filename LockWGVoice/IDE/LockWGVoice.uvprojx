# Keil uVision project LockWGVoice.uvprojx, settings and files
target LockWGVoice (ARM-ADS)
  device: LPC1125JBD48/303 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IROM(0x00000000,0x10000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LockWGVoice +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c include: ..\Code\App;..\Code\Driver;..\Code\Main;..\Code\NXPLib;..\Code\NXPLib\CMSIS\lpc112x;..\Code\NXPLib\I2CINT;..\Code\RF315
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x1000 size 0xf000
  memory RVCT9: RAM 0x100000c0 size 0x1f40
  group Main
    ../Code/Main/: main.c
    ../Code/NXPLib/CMSIS/lpc112x/: startup_LPC112x.s system_LPC112x.c
  group App
    ../Code/App/: delay.c json.c md5.c network.c shell.c SysInfo.c SysTimer.c UpdateInfo.c
  group Driver
    ../Code/Driver/: DoorMagnet.c key.c led.c lock315.c pir.c W25qFlash.c wifi.c wt588d.c
  group NXPLib
    ../Code/NXPLib/: gpio.c iocon.c syscon.c timer.c uart.c wdt.c systick.c
  group RF315
    ../Code/RF315/: crc.c memory.c rf_time.c RFRx_OPEN.c RFTx_OPEN.c
