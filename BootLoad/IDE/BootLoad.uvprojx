# Keil uVision project BootLoad.uvprojx, settings and files
target BootLoad (ARM-ADS)
  device: LPC1125JBD48/303 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IROM(0x00000000,0x10000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: BootLoad +hex
  c flags: OneElfS=1 wLevel=2
  c include: ..\Code\App;..\Code\Driver;..\Code\Main;..\Code\NXPLib;..\Code\NXPLib\CMSIS\lpc112x
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group App
    ../Code/App/: iap.c UpdateInfo.c
  group Main
    ../Code/Main/: main.c
    ../Code/NXPLib/CMSIS/lpc112x/: system_LPC112x.c startup_LPC112x.s
  group Driver
    ../Code/Driver/: W25qFlash.c
  group NXPLib
    ../Code/NXPLib/: syscon.c gpio.c uart.c
