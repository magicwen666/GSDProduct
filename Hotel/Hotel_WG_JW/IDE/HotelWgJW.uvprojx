# Keil uVision project HotelWgJW.uvprojx, settings and files
target HotelWgJW (ARM-ADS)
  device: LPC1125JBD48/303 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IROM(0x00000000,0x10000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: HotelWgJW
  c flags: OneElfS=1 uC99=1 wLevel=2
  c include: ..\Code\App;..\Code\Driver;..\Code\Main;..\Code\RF315;..\Code\NXPLib;..\Code\NXPLib\CMSIS\lpc112x;..\Code\NXPLib\I2CINT
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x1000 size 0xf000
  memory RVCT9: RAM 0x100000c0 size 0x1f40
  group Main
    ../Code/Main/: main.c
    ../Code/NXPLib/CMSIS/lpc112x/: system_LPC112x.c startup_LPC112x.s
  group App
    ../Code/App/: delay.c shell.c SysTimer.c SysInfo.c JwLock.c frame.c KeyMgr.c UpdateInfo.c
  group Driver
    ../Code/Driver/: beep.c BleS02.c key.c W25qFlash.c rs485.c
  group NXPLib
    ../Code/NXPLib/: uart.c timer.c systick.c syscon.c gpio.c iocon.c wdt.c
