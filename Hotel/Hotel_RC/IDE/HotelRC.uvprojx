# Keil uVision project HotelRC.uvprojx, settings and files
target HotelRC (ARM-ADS)
  device: LPC1125JBD48/303 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IROM(0x00000000,0x10000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: GHK-RM-MK +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: ..\Code\App;..\Code\Driver\et6290;..\Code\Driver;..\Code\Main;..\Code\NXPLib;..\Code\NXPLib\CMSIS\lpc112x;..\Code\NXPLib\I2CINT
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Main
    ../Code/Main/: main.c
    ../Code/NXPLib/CMSIS/lpc112x/: system_LPC112x.c startup_LPC112x.s
  group App
    ../Code/App/: network.c delay.c interrupt.c sys.c keycolor.c scr_key.c conf_key.c ps.c
  group Driver
    ../Code/Driver/et6290/: et6290.c
    ../Code/Driver/: board_ir.c board_key.c board_led.c board_light.c board_rs485.c board_time.c board_wdt.c door.c board_flash.c
  group NXPLib
    ../Code/NXPLib/: gpio.c i2c.c iocon.c syscon.c systick.c timer.c uart.c wdt.c iap.c
    ../Code/NXPLib/I2CINT/: I2CINT.c
